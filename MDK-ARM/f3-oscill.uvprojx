# Keil uVision project f3-oscill.uvprojx, settings and files
target f3-oscill Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: f3-oscill Configuration +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,ARM_MATH_CM4
  c misc: --C99
  c include: ..\Inc;         ..\Drivers\STM32F3xx_HAL_Driver\Inc;         ..\Drivers\CMSIS\Include;         ..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;     ..\Src\usb;   ../Inc;   ../Drivers/STM32F3xx_HAL_Driver/Inc;   ../Drivers/CMSIS/Include;   ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;  ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c main.c misc.c oscill.c oscill_config.s nakedConfig.txt shieldedConfig.txt
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
    ../Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_sin_q15.c
    ../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f303xc.s
  group Application/USB
    ../Src/usb/: usbd_oscill.c usb_device.c usbd_conf.c usbd_desc.c usbd_oscill_if.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
